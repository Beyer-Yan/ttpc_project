# Keil uVision project ttpc.uvprojx, settings and files
target STM32F407ZGT6 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ttpc
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group dbg
    ../dbg/: debug.c buffer.c buffer.h sendchar.c
  group include
    ../include/: ttpconstants.h ttpdebug.h ttpdef.h ttpservice.h
  group mac
    ../mac/: cycles.c mac_svc.c msg.c prp.c psp.c slots.c ttpc_ctl.c ttpc_mac.h
  group protocol
    ../protocol/: ack.c clique.c ext_sync.c guardian.c integrate.c life.c maintain.c membership.c protocol.h state_machine.c sync.c transport.c ttpc_startup.c
    ../dbg/: Retarget.c
  group virthw
    ../virthw/: adjtime.c clock.c dma.c irq.c triggers.c virhw.h watchdog.c xfer.c
